options:
  parameters:
    author: carlos
    copyright: UIS
    generate_options: qt_gui
    id: Receptor_fm
    output_language: python
    title: Receptor fm
  states: {}

blocks:
- name: IF_Gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: VGA_Gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 85e6
    step: '100'
    stop: 100e6
    value: 95.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '250000'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    type: intx
    value: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 70e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 250e3
    fc: freq
    fftsize: '1024'
    name: '"Espectro audio demodulado"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Espectro señal recibida"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '96'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    gain: IF_Gain
    samp_rate: samp_rate
    type: fc32
    vga: VGA_Gain
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
