options:
  parameters:
    author: Carlos
    copyright: UIS
    generate_options: qt_gui
    id: Transmisor_FM
    output_language: python
    title: Transmisor_FM
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 86e6
    step: '250'
    stop: 500e6
    value: 430e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '45'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '250e-3'
    stop: '10'
    value: '1'
  states: {}
- name: Quadrature_Rate
  id: parameter
  parameters:
    type: intx
    value: '192000'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: Quadrature_Rate
    tau: '50e-6'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    type: intx
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/carlos/Descargas/test.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '192000'
    fc: freq
    fftsize: '2048'
    name: '"Espectro Señal Transmitida"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    name: Señal Transmitida
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Quadrature_Rate
    interp: samp_rate
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: rf_gain
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_wfm_tx_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
